<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>System</name>
    <file>
      <name>$PROJ_DIR$\..\System\sys_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\System\sys_eeprom.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\System\sys_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\System\sys_optionByte.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\System\sys_pwm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\System\sys_task.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\System\sys_tim2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\System\sys_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\System\sys_vector.c</name>
    </file>
  </group>
</project>


